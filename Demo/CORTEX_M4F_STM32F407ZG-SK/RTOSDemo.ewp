# IAR project RTOSDemo.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ; board\; Libraries\CMSIS\ST\STM32F4xx\Include; Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\Source\include; ..\..\Source\portable\IAR\ARM_CM4F; ..\Common\include; User
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: readme.txt
  group Common Demo Source
    ../Common/Minimal/: BlockQ.c blocktim.c countsem.c death.c dynamic.c flash.c GenQTest.c integer.c PollQ.c recmutex.c semtest.c sp_flop.c
  group FreeRTOS_Source
    ../../Source/: list.c queue.c tasks.c timers.c
  group FreeRTOS_Source/Portable
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group ST_and_IAR_code/board
    board/: stm32f4_discovery.c
  group ST_and_IAR_code/startup
    startup/: startup_stm32f4xx.s system_stm32f4xx.c
  group ST_and_IAR_code/STM32F4xx_StdPeriph_Driver
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ./: FreeRTOSConfig.h main.c ParTest.c RegTest.s stm32f4xx_it.c
    User/: robot_couplings.c robot_debug.c robot_driver.c robot_encoder.c robot_move.c robot_status.c robot_test.c
